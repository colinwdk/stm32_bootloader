# Keil uVision project stm32f103_bootloader.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: STM32-FD-FLASHLED +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\user;.\CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./startup/: startup_stm32f10x_hd.s
  group USR
    ./user/: main.c stm32f103_flash_u.c stm32f103_uart_u.c
  group FWlib
    ./FWlib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_flash.c stm32f10x_usart.c
  group CMSYS
    ./CM3/: core_cm3.c system_stm32f10x.c
  group readme
    ./user/: readme.txt
